# Keil uVision project stm32f769-disco-demo.uvprojx, settings and files
target stm32f769-disco-demo (ARM-ADS)
  device: STM32F769NIHx STMicroelectronics
  cpu: IRAM(0x20000000-0x2007FFFF) IROM(0x8000000-0x81FFFFF)  CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE
  output: stm32f769-disco-demo +hex
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F769xx
  c include: ../Inc;  ../Middlewares/Third_Party/LwIP/src/include;  ../Middlewares/Third_Party/LwIP/system;  ../Drivers/STM32F7xx_HAL_Driver/Inc;  ../Drivers/STM32F7xx_HAL_Driver/Inc/Legacy;  ../Middlewares/Third_Party/FreeRTOS/Source/include;  ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM7/r0p1;  ../Middlewares/Third_Party/LwIP/src/include/netif/ppp;  ../Drivers/CMSIS/Device/ST/STM32F7xx/Include;  ../Middlewares/Third_Party/LwIP/src/include/lwip;  ../Middlewares/Third_Party/LwIP/src/include/lwip/apps;  ../Middlewares/Third_Party/LwIP/src/include/lwip/priv;  ../Middlewares/Third_Party/LwIP/src/include/lwip/prot;  ../Middlewares/Third_Party/LwIP/src/include/netif;  ../Middlewares/Third_Party/LwIP/src/include/compat/posix;  ../Middlewares/Third_Party/LwIP/src/include/compat/posix/arpa;  ../Middlewares/Third_Party/LwIP/src/include/compat/posix/net;  ../Middlewares/Third_Party/LwIP/src/include/compat/posix/sys;  ../Middlewares/Third_Party/LwIP/src/include/compat/stdc;  ../Middlewares/Third_Party/LwIP/system/arch;  ../Drivers/CMSIS/Include; ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2
  asm include: ..\Inc
  library: MicroLIB
  group Application/MDK-ARM
    ./: startup_stm32f769xx.s
  group Application/User
    ../Src/: main.c freertos.c lwip.c ethernetif.c stm32f7xx_it.c stm32f7xx_hal_msp.c stm32f7xx_hal_timebase_tim.c
  group Drivers/STM32F7xx_HAL_Driver
    ../Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal_eth.c stm32f7xx_hal_rcc.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_flash.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal_gpio.c stm32f7xx_hal_dma.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal_pwr.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_cortex.c stm32f7xx_hal.c stm32f7xx_hal_i2c.c stm32f7xx_hal_i2c_ex.c stm32f7xx_hal_exti.c stm32f7xx_hal_adc.c stm32f7xx_hal_adc_ex.c stm32f7xx_hal_crc.c stm32f7xx_hal_crc_ex.c stm32f7xx_hal_dma2d.c stm32f7xx_hal_dsi.c stm32f7xx_ll_fmc.c stm32f7xx_hal_sdram.c stm32f7xx_hal_cec.c stm32f7xx_hal_iwdg.c stm32f7xx_hal_ltdc.c stm32f7xx_hal_ltdc_ex.c stm32f7xx_hal_qspi.c stm32f7xx_hal_rtc.c stm32f7xx_hal_rtc_ex.c stm32f7xx_hal_sai.c stm32f7xx_hal_sai_ex.c stm32f7xx_ll_sdmmc.c stm32f7xx_hal_mmc.c stm32f7xx_hal_spdifrx.c stm32f7xx_hal_spi.c stm32f7xx_hal_spi_ex.c stm32f7xx_hal_tim.c stm32f7xx_hal_tim_ex.c stm32f7xx_hal_uart.c stm32f7xx_hal_uart_ex.c stm32f7xx_hal_pcd.c stm32f7xx_hal_pcd_ex.c stm32f7xx_ll_usb.c stm32f7xx_hal_wwdg.c
  group Drivers/CMSIS
    ../Src/: system_stm32f7xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM7/r0p1/: port.c
  group Middlewares/LwIP
    ../Middlewares/Third_Party/LwIP/src/netif/ppp/: auth.c ccp.c chap_ms.c chap-md5.c chap-new.c demand.c eap.c eui64.c fsm.c ipcp.c ipv6cp.c lcp.c magic.c mppe.c multilink.c ppp.c pppapi.c pppcrypt.c pppoe.c pppol2tp.c pppos.c upap.c utils.c vj.c ecp.c
    ../Middlewares/Third_Party/LwIP/src/netif/: bridgeif.c bridgeif_fdb.c ethernet.c lowpan6.c lowpan6_ble.c lowpan6_common.c slipif.c zepif.c
    ../Middlewares/Third_Party/LwIP/src/api/: api_lib.c api_msg.c err.c if_api.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../Middlewares/Third_Party/LwIP/src/core/: altcp.c altcp_alloc.c altcp_tcp.c def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    ../Middlewares/Third_Party/LwIP/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
    ../Middlewares/Third_Party/LwIP/src/core/ipv6/: dhcp6.c ethip6.c icmp6.c inet6.c ip6.c ip6_addr.c ip6_frag.c mld6.c nd6.c
    ../Middlewares/Third_Party/LwIP/system/OS/: sys_arch.c
    ../Middlewares/Third_Party/LwIP/src/apps/mqtt/: mqtt.c
software components: CMSIS:CORE 4.3.0
